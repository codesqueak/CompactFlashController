# Repository codesqueak/CompactFlashController

File README.md:

# NAS-GEM-80 Compact Flash Card 1.2

This card is to allow a compact flash module to be used in conjunction with an 80-Bus computer

## Introduction

The board is a standard 8x8 Nascom / Gemini / MAP-80 format card.  It features:

1. Port selection with a base between 0x80 and 0xF0
2. 8 bit operation in LBA mode (max 2**28 sectors, approximately 130GB )
3. An aux power connector for adaptors
4. Read / Write and Busy LED's

## Interface - A Brief overview

Addresses are offsets from the base address selected

| Address | Read | Write               |
|---------|------|---------------------|
| 0x00 | Data | Data                |
| 0x01 | Error Code  | Feature Select      |
| 0x02 | Sectors to Transfer | Sectors to Transfer |
| 0x03 | LBA 0..7 | LBA 0..7            |
| 0x04 | LBA 8..15 | LBA 8..15           |
| 0x05 | LBA 16..23 | LBA 16..23          |
| 0x06 | LBA 24..27 | LBA 16..23          |
| 0x07 | Status | Write Command       |

The following command sequences are sufficient to verify if a card if functional

### Select 8 Bit mode

Addresses are offsets from the base address selected

Write 0x01 to 0x01 - 8 bit mode

Write 0xEF to 0x07 - Set features

### Set Sector Count

Write 0x01 to 0x02 - Transfer one sector

### Select Sector to Read / Write

Write 0x01 to 0x03 - Select address 0x0000001

Write 0x00 to 0x04

Write 0x00 to 0x05

Write 0xE0 to 0x06

### Disable Cache

... otherwise your data won't stick !

Write 0x82 to 0x01 - Disable cache command

Write 0xEF to 0x07 - Set feature

### Read / Write

To read use the command 0x20, to write use the command 0x30 written to 0x07 and then read/write from
the data port 0x00

Between each byte you should check the status port to check if the next byte should be transferred.
However I have found the Z80 at 4MHz to be slow enough not to need this. YMMV

## Other

The CF card timing logic was adapted from a design by Tadeuzd Pycio

Details [Here](http://www.vtsys.pl/interface-compact-flash)

## KiCad design kicad/80bus.kicad_pcb

Parts:
D1, D2, D3, D4: LED; LED_D3.0mm
DC1, DC2, DC3, DC4, DC5, DC6, DC7, DC8: 100nF; C_Disc_D3.4mm_W2.1mm_P2.50mm
H1, H2, H3, H4: Mount; TestPoint_Plated_Hole_D3.0mm
J1: Conn_01x80NasBus; 80BusEdgeConnector
J2: Conn_02x25; PinHeader_2x25_P1.27mm_Vertical_CF
J3: Power; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
JP1: Link 1; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W7.62mm_P2.54mm_LowProfile
Q1, Q2: 2N3906; TO-92_Inline_Wide
R1, R8, R12: 1K2; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R2, R7: 2K2; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R3, R6, R9, R13, R14, R15: 4K7; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R4: 470; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R5: 1K; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R10, R11: 10K; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
SW1: SW_DIP_x08; DIP-16_W7.62mm_Socket
TP1: 0V; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: ~{RD Enable}; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3: ~{WR Enable}; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP4: ~{SELECT}; TestPoint_THTPad_D2.0mm_Drill1.0mm
Tant1, Tant2, Tant3, Tant4, Tant5, Tant6: 10uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
U1: 7406; DIP-14_W7.62mm_Socket
U2: 74LS74; DIP-14_W7.62mm_Socket
U3, U8: 74LS32; DIP-14_W7.62mm_Socket
U4, U5, U6: 74LS244; DIP-20_W7.62mm_Socket
U7: 74LS138; DIP-16_W7.62mm_Socket

Connections:
/BD0: J2.21, U4.8 (I3a), U5.12 (O3a)
/BD1: J2.22, U4.6 (I2a), U5.14 (O2a)
/BD2: J2.23, U4.4 (I1a), U5.16 (O1a)
/BD3: J2.2, U4.2 (I0a), U5.18 (O0a)
/BD4: J2.3, U4.11 (I0b), U5.9 (O0b)
/BD5: J2.4, U4.13 (I1b), U5.7 (O1b)
/BD6: J2.5, U4.15 (I2b), U5.5 (O2b)
/BD7: J2.6, U4.17 (I3b), U5.3 (O3b)
A0: J1.30, U6.8 (I3a)
A1: J1.31, U6.6 (I2a)
A2: J1.32, U6.4 (I1a)
A3: J1.33, U6.2 (I0a)
A4: J1.34, U6.11 (I0b)
A5: J1.35, U6.13 (I1b)
A6: J1.36, U6.15 (I2b)
A7: J1.37, U6.17 (I3b)
BA0: J2.20, U6.12 (O3a)
BA1: J2.19, U6.14 (O2a)
BA2: J2.18, U6.16 (O1a)
BA3: U6.18 (O0a), U7.4 (E1)
BA4: U6.9 (O0b), U7.1 (A0)
BA5: U6.7 (O1b), U7.2 (A1)
BA6: U6.5 (O2b), U7.3 (A2)
BA7: U1.9, U2.10 (~S), U6.3 (O3b)
CLK: J1.5, U2.3 (C), U2.11 (C), U3.12
D0: J1.50, U4.12 (O3a), U5.8 (I3a)
D1: J1.51, U4.14 (O2a), U5.6 (I2a)
D2: J1.52, U4.16 (O1a), U5.4 (I1a)
D3: J1.53, U4.18 (O0a), U5.2 (I0a)
D4: J1.54, U4.9 (O0b), U5.11 (I0b)
D5: J1.55, U4.7 (O1b), U5.13 (I1b)
D6: J1.56, U4.5 (O2b), U5.15 (I2b)
D7: J1.57, U4.3 (O3b), U5.17 (I3b)
GND: DC1.2, DC2.2, DC3.2, DC4.2, DC5.2, DC6.2, DC7.2, DC8.2, J1.1 (Pin_1_0v), J1.2 (Pin_2_0v), J1.3 (Pin_3_0v), J1.4 (Pin_4_0v), J2.1, J2.8, J2.9, J2.10, J2.11, J2.12, J2.14, J2.15, J2.16, J2.17, J2.39, J2.50, J3.2, J3.3, R1.2, R8.2, R12.2, TP1.1, Tant1.2, Tant2.2, Tant3.2, Tant4.2, Tant5.2, Tant6.2, U1.3, U1.7 (GND), U1.13, U2.7 (GND), U3.5, U3.7 (GND), U4.10 (GND), U5.10 (GND), U6.1 (OEa), U6.10 (GND), U6.19 (OEb), U7.8 (GND), U8.4, U8.5, U8.7 (GND), U8.9, U8.10, U8.12, U8.13
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), R4.2
unnamed: D2.1 (K), J2.45
unnamed: D3.2 (A), Q2.3 (C)
unnamed: D3.1 (K), R8.1
unnamed: D4.2 (A), Q1.3 (C)
unnamed: D4.1 (K), R12.1
unnamed: J1.16, J1.17
unnamed: J1.19, J1.20
unnamed: J2.32, R13.1
unnamed: J2.36, R14.1
unnamed: J2.44, R15.1
unnamed: J2.46, R3.1
unnamed: JP1.1 (A), U1.10
unnamed: Q1.2 (B), R9.1, R10.2
unnamed: Q2.2 (B), R6.1, R11.2
unnamed: R2.1, U1.8, U1.11
unnamed: R5.2, U1.1, U1.6
unnamed: U2.5 (Q), U3.10
unnamed: U2.1 (~R), U3.11
unnamed: U2.9 (Q), U7.5 (E2)
unnamed: U3.3, U3.4
unnamed: SW1.1, U7.15 (O0)
unnamed: SW1.2, U7.14 (O1)
unnamed: SW1.3, U7.13 (O2)
unnamed: SW1.4, U7.12 (O3)
unnamed: SW1.5, U7.11 (O4)
unnamed: SW1.6, U7.10 (O5)
unnamed: SW1.7, U7.9 (O6)
unnamed: SW1.8, U7.7 (O7)
VCC: D1.2 (A), DC1.1, DC2.1, DC3.1, DC4.1, DC5.1, DC6.1, DC7.1, DC8.1, J1.75 (Pin_75_+5v), J1.76 (Pin_76_+5v), J1.77 (Pin_77__+5v), J1.78 (Pin_78__+5v), J2.13, J2.38, J3.1, Q1.1 (E), Q2.1 (E), R2.2, R3.2, R4.1, R5.1, R7.1, R10.1, R11.1, R13.2, R14.2, R15.2, Tant1.1, Tant2.1, Tant3.1, Tant4.1, Tant5.1, Tant6.1, U1.14 (VCC), U2.4 (~S), U2.12 (D), U2.14 (VCC), U3.14 (VCC), U4.20 (VCC), U5.20 (VCC), U6.20 (VCC), U7.16 (VCC), U8.14 (VCC)
~BIORQ: J1.26, U2.13 (~R)
~BRD: J1.29, U2.2 (D), U3.9, U3.13
~BRESET: J1.14, J2.41
~BWR: J1.28, U3.2
~DBDR: J1.13, R7.2, U1.2
~IO_RD_ENABLE_CS: R6.2, U1.5, U4.1 (OEa), U4.19 (OEb), U8.3
~IO_RD_ENABLE: J2.34, TP2.1, U3.8, U8.1
~IO_WR_ENABLE: J2.35, R9.2, TP3.1, U3.6, U5.1 (OEa), U5.19 (OEb)
~M1: J1.25, U7.6 (E3)
~NASIO: J1.12, JP1.2 (B)
~SELECT: J2.7, SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16, TP4.1, U3.1, U8.2

Notes on the sheet:
Power Decoupling
IC Decoupling
Decode 1AAA_0xxx
1101_0xxx
1011_0xxx
1100_0xxx
Base Address 1000_0000
1010_0xxx
Unused Gates
1001_0xxx
1111_0xxx
1000_0xxx
1110_0xxx

Board: 2 copper layers, 203.2 x 203.2 mm, 58 parts (1 on the bottom side), 76 nets.

Other parts of the board:
G1: LOGO; sleepymouse_small
G001: LOGO; qr code

## Commit log

2023-08-14 Initial file upload
2023-10-08 Fixing prototype issues
2023-10-17 Design notes
2023-11-02 Documentation
2023-12-06 Minor tweaks
2025-05-04 Docs and Kicad 9
